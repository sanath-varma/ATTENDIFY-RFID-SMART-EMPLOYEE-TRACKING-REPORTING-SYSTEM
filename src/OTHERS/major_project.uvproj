# Keil uVision project major_project.uvproj, settings and files
target major_project (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: major_project +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Interrupt_admin
    ./: Startup.s interrupt.c
  group Admin_Edit
    ./: admin.c
  group LCD
    ./: lcd.c delay.c
  group test
    ./: test.c
  group RTC
    ./: rtc.c rtc_edit.c
  group KEYPAD
    ./: kpm.c kpm.h
  group UART_1
    ./: uart1.c types.h defines.h
  group SPI
    ./: SPI_Protocol.c
  group UART_0
    ./: uart.c
